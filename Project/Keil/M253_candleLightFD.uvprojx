# Keil uVision project M253_candleLightFD.uvprojx, settings and files
target M253_candleLightFD (6220000::V6.22::ARMCLANG)
  device: M253LE3AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: M253_candleLightFD +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: .\;..\..\User;..\..\Protocol;..\..\Driver\CMSIS\Core\Include;..\..\Driver\Device\Nuvoton\M253\Include;..\..\Driver\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\Driver\Device\Nuvoton\M253\Source\ARM\APROM.scf
  group CMSIS
    ../../Driver/Device/Nuvoton/M253/Source/: system_M253.c
    ../../Driver/Device/Nuvoton/M253/Source/ARM/: startup_M253.c
  group User
    ../../User/: main.c system_init.c descriptors.c usbd_gs_can.c m253_canfd.c timestamp.c led.c
  group Library
    ../../Driver/StdDriver/src/: clk.c sys.c usbd.c canfd.c timer.c uart.c gpio.c retarget.c
